# Keil uVision project sensorR.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sensorR
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L476RGTx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L476RGTx/STCubeGenerated/Inc/: stm32l4xx_it.h
    ./: lis331dlh_driver.h MAX30101_new.h.h lis331dlh_driver.c MAX30101_new.c
software components: CMSIS:CORE 5.0.2, Device:STM32Cube HAL:Common 1.9.0, Device:STM32Cube HAL:Cortex 1.9.0, Device:STM32Cube HAL:DMA 1.9.0, Device:STM32Cube HAL:GPIO 1.9.0, Device:STM32Cube HAL:I2C 1.9.0, Device:STM32Cube HAL:PWR 1.9.0, Device:STM32Cube HAL:RCC 1.9.0, Device:STM32Cube HAL:UART 1.9.0, Device:Startup 1.3.1
